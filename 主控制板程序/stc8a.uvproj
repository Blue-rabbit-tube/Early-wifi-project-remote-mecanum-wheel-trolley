# Keil uVision project stc8a.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: stc8a +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c uart2.c uart2.h i2c.c i2c.h servo.c servo.h delay.c delay.h motor.c motor.h uart1.c uart1.h
